<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Sep 18 11:37:01 2025</timestamp>
			<uuid>{c7762b4f-cc30-4c53-a13a-4b6395bee367}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/viterbi/08/vemurina/work_gpdk045/lab0/INV_2X/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/viterbi/08/vemurina/work_gpdk045/lab0/INV_2X/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/viterbi/08/vemurina/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/viterbi/08/vemurina/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
